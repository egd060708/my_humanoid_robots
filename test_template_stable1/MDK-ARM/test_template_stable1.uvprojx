# Keil uVision project test_template_stable1.uvprojx, settings and files
target test_template_stable1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_template_stable1 +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,ARM_MATH_CM4,__ASM__=__asm,STM32F407xx
  c include: ../Core/Inc;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USP;../SRML;../USP/Middlewares/Systemview;../Drivers/CMSIS/DSP/Include;../Middlewares/FreeRTOS_port;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USP/Drivers;../USP/Drivers/BetaFPV;../USP/Middlewares/Robot_Module;..\USP\Application\Robot
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\STM32F407VET6.sct
  group USP
    ../USP/: srml_config.h
  group USP/Application
    ../USP/: internal.h
    ../USP/Application/: Service_Communication.cpp Service_Debug.cpp Service_Device.cpp System_Config.cpp System_DataPool.cpp
  group USP/Application/Robot
    ../USP/Application/Robot/: Leg_intergration.cpp
  group USP/Middlewares/Robot_Module
    ../USP/Middlewares/Robot_Module/: arm_controller.h arm_def.h myMatrices.h Upper_Public.h
  group USP/Middlewares/SystemView
    ../USP/Middlewares/Systemview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
  group USP/Drivers
    ../USP/Drivers/BetaFPV/: BetaFPV.h
  group SRML
    ../SRML/: SRML.h srml_std_lib.h srml_std_lib.cpp
  group SRML/Middlewares/Abstract_class_library
    ../SRML/Middlewares/Abstract_class_library/: abstractIMU.h abstractMotor.h
  group SRML/Middlewares/Algorithm
    ../SRML/Middlewares/Algorithm/MultiTurnRecorder/: MultiTurnRecorder.h
    ../SRML/Middlewares/Algorithm/Filters/: filters.h SecondButterworthLPF.h
    ../SRML/Middlewares/Algorithm/DiffCalculator/: DiffCalculator.h
    ../SRML/Middlewares/Algorithm/PID/: PID.cpp
    ../SRML/Middlewares/Algorithm/filters/: filters.cpp
    ../SRML/Middlewares/Algorithm/KalmanFilter/: kalman_filter.h
    ../SRML/Middlewares/Algorithm/Statistics/: statistics.h
  group SRML/Middlewares/Module
    ../SRML/Middlewares/Module/Chassis/: chassis.cpp MecenumChassis.cpp
    ../SRML/Middlewares/Module/Digital_Power/: digital_Power.cpp DP_power_ctrl.cpp
  group SRML/Middlewares/Protocol
    ../SRML/Middlewares/Protocol/: SerialLineIP.cpp
  group SRML/Middlewares/Utility
    ../SRML/Middlewares/Utility/: sys_analysis.cpp sys_log.cpp
    ../SRML/Middlewares/Utility/VofaMonitor/: VofaMonitor.cpp
    ../SRML/Middlewares/Utility/UpperMonitor/: UpperMonitor.cpp
    ../SRML/Middlewares/Utility/AsuwaveMonitor/: AsuwaveMonitor.cpp
    ../SRML/Middlewares/Utility/Easylogger/: elog_port.cpp elog.c elog_utils.c
  group SRML/Drivers/Components
    ../SRML/Drivers/Components/: drv_can.c drv_flash.c drv_i2c.c drv_spi.c drv_timer.c drv_VirtualCom.c drv_uart.cpp drv_memory.cpp SRML_Timer.cpp
  group SRML/Drivers/Devices
    ../SRML/Drivers/Devices/DR16/: dr16.cpp
    ../SRML/Drivers/Devices/Referee/: referee.cpp
    ../SRML/Drivers/Devices/FS_I6X/: FS_I6X.cpp
  group SRML/Drivers/Devices/IMU
    ../SRML/Drivers/Devices/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_component.c mpu6050.c
    ../SRML/Drivers/Devices/Lpms_Be2/: LPMS_BE2.cpp
  group SRML/Drivers/Devices/Motor
    ../SRML/Drivers/Devices/Motor_Dji/: motor_dji.h
    ../SRML/Drivers/Devices/HT_04/: HT04.cpp
    ../SRML/Drivers/Devices/MF9025_V2/: MF9025_v2.cpp
    ../SRML/Drivers/Devices/Motor_DM/: motor_dm.cpp
    ../SRML/Drivers/Devices/Motor_CyberGear/: Motor_CyberGear.cpp
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS_port/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Retarget_IO
    ./: stdout_user.c stdin_user.c stderr_user.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
